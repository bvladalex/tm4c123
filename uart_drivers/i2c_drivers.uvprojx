# Keil uVision project i2c_drivers.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio_drivers_tm4c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drivers\inc;.\;.\drivers\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/src/: tm4c123_spi_driver.c tm4c123_gpio_driver.c tm4c123_i2c_driver.c tm4c123_uart_driver.c
  group project_files
    ./: main.c
  group inc
    ./drivers/inc/: TM4C123GH6PM_mcu1.h tm4c123_gpio_driver.h tm4c123_spi_driver.h tm4c123_i2c_driver.h tm4c123_uart_driver.h
  group CMSIS
    ./CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccs.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.1
